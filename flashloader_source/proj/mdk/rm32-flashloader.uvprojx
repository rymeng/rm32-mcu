# Keil uVision project rm32-flashloader.uvprojx, settings and files
target debug (6220000::V6.22::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: RT32F7
  AfterMake: cmd.exe /C copy ".\build\obj\%L" ".\build\flm\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG
  c include: ..\..\application\include;..\..\drivers\bsp\include;..\..\drivers\cmsis\core\include;..\..\drivers\cmsis\device\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter-file\flash-loader.sct
  group application
    ../../application/src/: algorithm.c framework.c
  group drivers/bsp
    ../../lib/bsp/src/: board.c
target release (6240000::V6.24::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RM32
  AfterMake: cmd.exe /C copy ".\build\obj\%L" ".\build\flm\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\application\include;..\..\lib\bsp\include;..\..\lib\cmsis\core\include;..\..\lib\cmsis\device\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter-file\rm32-flashloader.sct
