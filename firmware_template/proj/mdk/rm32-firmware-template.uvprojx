# Keil uVision project rm32-firmware-template.uvprojx, settings and files
target debug (6240000::V6.24::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: rm32-firmware-template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\application\include;..\..\lib\bsp\include;..\..\lib\cmsis\core\include;..\..\lib\cmsis\device\include;..\..\lib\middleware\ufifo\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\scatter-file\rm32-firmware-template.sct
  group application
    ../../application/src/: main.c
  group lib/bsp
    ../../lib/bsp/src/: board_clk.c board_delay.c board_print.c board_systick.c
  group lib/cmsis/device
    ../../lib/cmsis/device/src/: startup_rm32.c system_rm32.c
  group lib/middlewares/ufifo
    ../../lib/middleware/ufifo/src/: ufifo.c
